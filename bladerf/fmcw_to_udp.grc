options:
  parameters:
    author: popikeyshen
    generate_options: qt_gui
    id: fmcw_to_udp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwith
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e5
    step: '100000'
    stop: 20e6
    value: 20e6
    widget: slider
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 433e6
    step: 1e6
    stop: 5000e6
    value: 5000e6
    widget: slider
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '0'
    widget: slider
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: int(20000000)
  states: {}
- name: vco_freq
  id: variable
  parameters:
    value: int(1000000)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0.1'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 192.168.1.64
    port: '5000'
    psize: 1024*4
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_udp_sink_0_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 192.168.1.64
    port: '5000'
    psize: 1024*8
    type: complex
    vlen: '1024'
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: sample_rate
    sensitivity: 6.28e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '20'
    bb_gain1: '0'
    bw0: Bandwith
    corr1: '0'
    freq0: Frequency
    freq1: Frequency
    gain0: '30'
    gain1: '1'
    if_gain0: '20'
    if_gain1: '0'
    nchan: '2'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '40'
    bb_gain1: '40'
    bw0: Bandwith
    bw1: Bandwith
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: Frequency
    freq1: Frequency
    gain0: '40'
    gain1: '40'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '40'
    if_gain1: '40'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '100000'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    name: '"out1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_agc_xx_0, '0', blocks_streams_to_vector_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_1_0, '0']
- [analog_agc_xx_0_0, '0', blocks_streams_to_vector_0, '1']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_udp_sink_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '1']
- [fft_vxx_0, '0', blocks_complex_to_real_1, '0']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '1', analog_agc_xx_0_0, '0']
- [osmosdr_source_0, '1', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
