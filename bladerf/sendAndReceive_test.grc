options:
  parameters:
    author: popikeyshen
    generate_options: qt_gui
    id: block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwith
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e5
    step: '100000'
    stop: 20e6
    value: 1e6
    widget: slider
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 433e6
    step: 1e6
    stop: 5000e6
    value: 2400e6
    widget: slider
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: int(10000000)
  states: {}
- name: vco_freq
  id: variable
  parameters:
    value: int(1000000)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2e6
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2e3
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2e5
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 192.168.1.64
    noblock: 'True'
    port: '5000'
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 192.168.148.54
    port: '5000'
    psize: '1024'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 192.168.92.54
    port: '5000'
    psize: 1024*4
    type: complex
    vlen: '2'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: 10e6
    sensitivity: 6.28e6
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: sample_rate
    sensitivity: 2* 3.14 *   vco_freq  / 1.0
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '1'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '1'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '20'
    bb_gain1: '0'
    bw0: Bandwith
    corr1: '0'
    freq0: Frequency
    freq1: Frequency
    gain0: '30'
    gain1: '1'
    if_gain0: '20'
    if_gain1: '0'
    nchan: '2'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '40'
    bb_gain1: '40'
    bw0: Bandwith
    bw1: Bandwith
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: Frequency
    freq1: Frequency
    gain0: '40'
    gain1: '40'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '40'
    if_gain1: '40'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    rate: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '500000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    name: '"out1"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: 10e6
    type: complex
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_streams_to_vector_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_1_0, '0']
- [analog_agc_xx_0_0, '0', blocks_streams_to_vector_0, '1']
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [analog_sig_source_x_0_0, '0', hilbert_fc_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_streams_to_vector_0, '0']
- [analog_sig_source_x_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [analog_sig_source_x_0_0_1, '0', hilbert_fc_0_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '1']
- [blocks_add_xx_0, '0', qtgui_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_delay_0, '0', qtgui_sink_x_1_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_streams_to_vector_0, '0', blocks_tcp_server_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '0']
- [blocks_vco_c_0, '0', osmosdr_sink_0, '1']
- [blocks_vco_f_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_add_xx_0, '0']
- [hilbert_fc_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', blocks_udp_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1_0, '0']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '1', analog_agc_xx_0_0, '0']
- [osmosdr_source_0, '1', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '1', qtgui_sink_x_1_0_0, '0']

metadata:
  file_format: 1
