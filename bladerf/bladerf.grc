options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Bandwith
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1.5e6
    step: '1000'
    stop: 28e6
    value: 22e6
    widget: slider
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1.000e6
    step: 100e3
    stop: 2.000e6
    value: 1.000e6
    widget: slider
  states: {}
- name: band
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: int(10000000)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2400000000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    freq0: '2400000000'
    gain0: '10'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: band
    freq0: Frequency
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: Bandwith
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.4e9
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
